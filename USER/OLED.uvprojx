# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\OLED;..\fg
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group fg
    ../fg/: cw2015.cpp cw2015_i2c.cpp
software components: CMSIS:CORE 5.0.2
